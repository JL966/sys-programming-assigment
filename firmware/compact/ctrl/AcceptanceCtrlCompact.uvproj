# Keil uVision project AcceptanceCtrlCompact.uvproj, settings and files
target AcceptanceCtrlCompact (MCS-51)
  device: STC15F2K60S2 Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: AcceptanceCtrlCompact +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\inc
  group Source Group 1
    ./source/: main.c compact_app.c compact_protocol.c
