# Keil uVision project AcceptanceDiagnostic.uvproj, settings and files
target AcceptanceDiagnostic (MCS-51)
  device: STC15F2K60S2 Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: AcceptanceDiagnostic +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\inc
  group Source Group 1
    ./source/: main.c diagnostic.c hardware.c STCBSP_V3.6.LIB
